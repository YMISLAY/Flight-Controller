# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\Version5.06)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Libraries\CMSIS;.\Libraries\STM32F4xx_HAL_Driver\Inc;.\User;.\Public;.\APP\led;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\rng;.\APP\wkup;.\APP\dma;.\APP\iic;.\APP\stm32_flash;.\APP\touch;.\APP\mpu6050;.\APP\mpu6050\eMPL;.\APP\control;.\APP\motor;.\APP\pid;.\APP\pwm;.\APP\tim;.\APP\nrf24l01;.\APP\ibus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f407xx.s
  group HAL_Driver
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group APP
    ./APP/led/: led.c
    ./APP/key/: key.c
    ./APP/iic/: iic.c
    ./APP/mpu6050/: mpu6050.c biquad_filter.c biquad_filter.h
    ./APP/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./APP/control/: control.c control.h
    ./APP/motor/: motor.c motor.h
    ./APP/pid/: pid.c pid.h
    ./APP/pwm/: pwm.c pwm.h
    ./APP/tim/: timer.c timer.h
    ./APP/nrf24l01/: NRF24L01.c NRF24L01.h NRF24L01_Define.h
    ./APP/ibus/: ibus.c ibus.h
  group Public
    ./Public/: system.c SysTick.c usart.c
